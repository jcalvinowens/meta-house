# Desktop/Workstation images

inherit packagegroup

RDEPENDS:${PN} = " \
	packagegroup-house-base \
	\
	htop \
	keymaps \
	lmsensors \
	set-locale-utf8 \
	tmux \
	usbutils \
	vim \
	"
