FILESEXTRAPATHS:prepend := "${THISDIR}/${BP}:"
SRC_URI += "file://icu-76.1-undo-pkgconfig-change-for-now.patch"
