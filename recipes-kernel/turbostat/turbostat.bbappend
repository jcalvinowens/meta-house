COMPATIBLE_HOST:libc-musl = '(x86_64.*|i.86.*)-linux'
