FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"
SRC_URI += "file://0001-input-sources-use-correct-function-to-get-attribute-.patch"
