PACKAGECONFIG:append = " fuse http libmtp samba"
